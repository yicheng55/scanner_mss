# IAR project LED_BOOSTER_PACK_DEMO_APP.ewp, settings and files
configuration MSP430G2452 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2452 MSP430G2452
  General.GStackSize2: 32
  General.GHeapSize2: 32
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\Configuration; ..\..\Source; ..\..\Source\driver; ..\..\..\..\..\..\..\Sources\llist; ..\..\..\..\..\..\..\Sources\mss\common; ..\..\..\..\..\..\..\Sources\mss\target\MSP-EXP430G2
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2452.xcl
  XLINK.XlinkStackSize: 1
configuration MSP430G2553 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  group (top)
    ../../Source/: demo_app.c demo_app.h
  group driver
    ../../Source/driver/: buzzer.c buzzer.h led_matrix.c led_matrix.h
  group mss_source/cfg
    ../../Configuration/: llist_cfg.h mss_cfg.h
  group mss_source/llist
    ../../../../../../../Sources/llist/: llist.c llist.h
  group mss_source/mss/common
    ../../../../../../../Sources/mss/common/: mss.c mss.h mss_event.c mss_event.h mss_int.h mss_mem.c mss_mem.h mss_mque.c mss_mque.h mss_sema.c mss_sema.h mss_timer.c mss_timer.h
  group mss_source/mss/target/MSP-EXP430G2
    ../../../../../../../Sources/mss/target/MSP-EXP430G2/: dev_types.h mss_hal.c mss_hal.h mss_hal_int.h
