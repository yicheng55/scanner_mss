# Keil uVision project tag.uvprojx, settings and files
target Tag (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: IROM(0x00000000,0x00400000) IRAM(0x20000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Master_M8107 +hex
  AfterMake: ".\HexToBin2.bat"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG DEBUG
  c include: ..\..\common\include;..\..\common\source;..\..\..\common\include;..\..\..\common\source;..\..\Library\CMSIS\Include;..\..\Library\Device\AMICCOM\AMICCOM_CM0\include;..\..\Library\Driver\inc;..\..\Library\common\inc;..\..\Library\A8107M\inc;..\library\device\amiccom\amiccom_cm0\include;..\library;..\library\cmsis\Include;..\library\Driver\inc;..\library\A8107M\inc;..\library\common\inc
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group Device
    ../../library/device/amiccom/amiccom_cm0/source/: system_A8107M.c
    ../../library/device/amiccom/amiccom_cm0/source/ARM/: system_OTA_A8107M.s
  group Common
    ../../library/common/src/: retarget.c uart_stdout.c
    ../../common/source/: RfCommunication.c Utility.c
    ../../../common/source/: Debug.c
  group Driver
    ../../library/A8107M/src/: SPI.c RTC.c Flash.c slptimer.c
    ../../library/Driver/src/: uart.c timer.c dualtimer.c
    ../../library/A8107M/lib/: A8107M_RFLib.lib
  group App
    ./sources/: main.c init.c isr.c M8107.c RFpacket.c tagdefine.c led.c fifo.c
  group OTA
    ../../common/source/OTA/: ota_fu.c OTA.s UpdateCode.s
  group jbig
    ./sources/jbig/: jbig_ar.c jbig85.c
  group TAG_RBW_2.9_inch
    ../../common/source/TAG_RBW_2.9_inch/: EPaperSSD1675A.c
  group TAG_RBW_2.13_inch
    ../../common/source/TAG_RBW_2.13_inch/: EPaperSSD1675A.c
  group TAG_BW_2.9_inch
    ../../common/source/TAG_BW_2.9_inch/: EPaperSSD1608.c
target TAG_RBW_2.9_inch (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: as above
  output: Master_M8107 +hex
  AfterMake: ".\HexToBin2.bat"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG DEBUG
  c include: as above
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
target TAG_RBE_2.13_inch (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: as above
  output: Master_M8107 +hex
  AfterMake: ".\HexToBin2.bat"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG DEBUG
  c include: as above
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
