# Keil uVision project repeater.uvprojx, settings and files
target Rpt_M8107_500msOneRF (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: IROM(0x00000000,0x00400000) IRAM(0x20000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Rpt_M8107_500msOneRF +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/Rpt_M8107_500msOneRF.bin ./Objects/Rpt_M8107_500msOneRF.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG DEBUG
  c include: ..\..\common\include;..\..\common\source;..\..\..\common\include;..\..\..\common\source;..\..\Library\CMSIS\Include;..\..\Library\Device\AMICCOM\AMICCOM_CM0\include;..\..\Library\Driver\inc;..\..\Library\common\inc;..\..\Library\A8107M\inc;..\library\device\amiccom\amiccom_cm0\include;..\library;..\library\cmsis\Include;..\library\Driver\inc;..\library\A8107M\inc;..\library\common\inc;.\sources;.\sources\M8107_500msOneRF
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Device
    ../../library/device/amiccom/amiccom_cm0/source/: system_A8107M.c
    ../../library/device/amiccom/amiccom_cm0/source/ARM/: startup_A8107M.s
  group Common
    ../../library/common/src/: retarget.c uart_stdout.c
    ../../common/source/: RfCommunication.c Utility.c
    ../../../common/source/: Debug.c
  group Driver
    ../../library/A8107M/src/: SPI.c RTC.c Flash.c slptimer.c
    ../../library/Driver/src/: uart.c timer.c dualtimer.c
    ../../common/source/: EPaperSSD1608.c
    ../../library/A8107M/lib/: A8107M_RFLib.lib
  group RptCommApp
    ./sources/: Board.c isr.c M8107.c RptDataFlash.c M8107RTC.c RptComm.c RptOTA.c RptIAP.c tagdefine.c
    ./sources/A7127RF_Driver/: A7127RF_Drv.c
  group M8107_500msOneRF
    ./sources/M8107_500msOneRF/: RFpacket.c RfTxPacket.c RptProc.c
  group M8107_A7127_500msDualRF
    ./sources/M8107_A7127_500msDualRF/: RFpacket.c RfTxPacket.c RptProc.c
  group M8107_A7127_TranstDualRF
    ./sources/M8107_A7127_TransDualRF/: RFpacket.c RptProc.c
  group A7127_500msOneRF
    ./sources/A7127_500msOneRF/: RFpacket.c RfTxPacket.c RptProc.c
  group A7127_M8107_500msDaulRF
    ./sources/A7127_M8107_500msDualRF/: RFpacket.c RfTxPacket.c RptProc.c
  group A7127_M8107_TransDualRF
    ./sources/A7127_M8107_TransDualRF/: RFpacket.c RptProc.c
  group User
    ./sources/: main.c
  group OTA
    ./sources/RptOTA/: ota_fu.c OTA.s UpdateCode.s
target Rpt_M8107_A7127_500msDualRF (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: as above
  output: Rpt_M8107_A7127_500msDualRF +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/Rpt_M8107_A7127_500msDualRF.bin ./Objects/Rpt_M8107_A7127_500msDualRF.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG DEBUG, USE_A7127RF_MODULE
  c include: ..\..\common\include;..\..\common\source;..\..\..\common\include;..\..\..\common\source;..\..\Library\CMSIS\Include;..\..\Library\Device\AMICCOM\AMICCOM_CM0\include;..\..\Library\Driver\inc;..\..\Library\common\inc;..\..\Library\A8107M\inc;..\library\device\amiccom\amiccom_cm0\include;..\library;..\library\cmsis\Include;..\library\Driver\inc;..\library\A8107M\inc;..\library\common\inc;.\sources;.\sources\A7127RF_Driver;.\sources\M8107_A7127_500msDualRF
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Rpt_M8107_A7127_TransDualRF (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: as above
  output: Rpt_M8107_A7127_TransDualRF +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG DEBUG, USE_A7127RF_MODULE, DUAL_RF_NO_500MS
  c include: ..\..\common\include;..\..\common\source;..\..\..\common\include;..\..\..\common\source;..\..\Library\CMSIS\Include;..\..\Library\Device\AMICCOM\AMICCOM_CM0\include;..\..\Library\Driver\inc;..\..\Library\common\inc;..\..\Library\A8107M\inc;..\library\device\amiccom\amiccom_cm0\include;..\library;..\library\cmsis\Include;..\library\Driver\inc;..\library\A8107M\inc;..\library\common\inc;.\sources;.\sources\A7127RF_Driver;.\sources\M8107_A7127_TransDualRF
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Rpt_A7127_500msOneRF (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: as above
  output: Rpt_A7127_500msOneRF +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/Rpt_A7127_500msOneRF.bin ./Objects/Rpt_A7127_500msOneRF.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG DEBUG
  c include: ..\..\common\include;..\..\common\source;..\..\..\common\include;..\..\..\common\source;..\..\Library\CMSIS\Include;..\..\Library\Device\AMICCOM\AMICCOM_CM0\include;..\..\Library\Driver\inc;..\..\Library\common\inc;..\..\Library\A8107M\inc;..\library\device\amiccom\amiccom_cm0\include;..\library;..\library\cmsis\Include;..\library\Driver\inc;..\library\A8107M\inc;..\library\common\inc;.\sources;.\sources\A7127RF_Driver;.\sources\A7127_500msOneRF
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Rpt_A7127_M8107_500msDualRF (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: as above
  output: Rpt_A7127_M8107_500msDualRF +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/Rpt_A7127_M8107_500msDualRF.bin ./Objects/Rpt_A7127_M8107_500msDualRF.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG DEBUG
  c include: ..\..\common\include;..\..\common\source;..\..\..\common\include;..\..\..\common\source;..\..\Library\CMSIS\Include;..\..\Library\Device\AMICCOM\AMICCOM_CM0\include;..\..\Library\Driver\inc;..\..\Library\common\inc;..\..\Library\A8107M\inc;..\library\device\amiccom\amiccom_cm0\include;..\library;..\library\cmsis\Include;..\library\Driver\inc;..\library\A8107M\inc;..\library\common\inc;.\sources;.\sources\A7127RF_Driver;.\sources\A7127_M8107_500msDualRF
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Rpt_A7127_M8107_TransDualRF (ARM-ADS)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: as above
  output: Rpt_A7127_M8107_TransDualRF +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/Rpt_A7127_M8107_TransDualRF.bin ./Objects/Rpt_A7127_M8107_TransDualRF.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG DEBUG
  c include: ..\..\common\include;..\..\common\source;..\..\..\common\include;..\..\..\common\source;..\..\Library\CMSIS\Include;..\..\Library\Device\AMICCOM\AMICCOM_CM0\include;..\..\Library\Driver\inc;..\..\Library\common\inc;..\..\Library\A8107M\inc;..\library\device\amiccom\amiccom_cm0\include;..\library;..\library\cmsis\Include;..\library\Driver\inc;..\library\A8107M\inc;..\library\common\inc;.\sources;.\sources\A7127RF_Driver;.\sources\A7127_M8107_TransDualRF
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
