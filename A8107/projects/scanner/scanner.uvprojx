# Keil uVision project scanner.uvprojx, settings and files
target Scanner (ARM-ADS)
  device: A8107M0 Amiccom
  pack: Amiccom.SoC_DFP.0.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x08000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Master_M8107
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG DEBUG
  c include: ..\..\common\include;..\..\common\source;..\..\..\common\include;..\..\..\common\source;..\..\Library\CMSIS\Include;..\..\Library\Device\AMICCOM\AMICCOM_CM0\include;..\..\Library\Driver\inc;..\..\Library\common\inc;..\..\Library\A8107M\inc;..\library\device\amiccom\amiccom_cm0\include;..\library;..\library\cmsis\Include;..\library\Driver\inc;..\library\A8107M\inc;..\library\common\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Device
    ../../library/device/amiccom/amiccom_cm0/source/: system_A8107M.c
    ../../library/device/amiccom/amiccom_cm0/source/ARM/: startup_A8107M.s
  group Common
    ../../library/common/src/: retarget.c uart_stdout.c
    ../../../common/source/: Debug.c
    ../../common/source/: RfCommunication.c Utility.c Encryption.c
  group Driver
    ../../library/A8107M/src/: SPI.c RTC.c Flash.c slptimer.c
    ../../library/Driver/src/: uart.c timer.c dualtimer.c
    ../../library/A8107M/lib/: A8107M_RFLib.lib
  group App
    ./sources/: main.c Board.c isr.c Scanner.c RfPpacket.c System.c Led.c NonVolatileMemory.c
  group Documents
    ./: Version.txt
